Commit message: Update URDF and add assets

File: joyrebot_gazebo_sim/urdf/rebot_b601_rs.urdf (robot description, URDF)
Before this commit: robot rebot_b601_rs, 10 links, 9 joints
Links:
- added link world
Joints:
- added joint base_fixed: type fixed, parent world, child base_link
